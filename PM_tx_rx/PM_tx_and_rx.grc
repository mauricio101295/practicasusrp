options:
  parameters:
    author: Camila Vinza
    copyright: '@CamiVinza'
    description: Modulacion PM
    generate_options: qt_gui
    id: PM_tx
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(22.05e3)
  states: {}
- name: frecuencia
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 89e6
  states: {}
- name: freqPM
  id: variable
  parameters:
    comment: |-
      Rango: 
      88Mhz - 108Mhz
    value: frecuencia
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: sensibility
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '5'
  states: {}
- name: PMmodsink
  id: virtual_sink
  parameters:
    stream_id: pmsignal
  states: {}
- name: PMmodsource
  id: virtual_source
  parameters:
    stream_id: pmsignal
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 48e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: sensibility
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/robert/Downloads/CantinaBand60 (mp3cut.net).wav
    repeat: 'True'
  states: {}
- name: integrate
  id: blocks_integrate_xx
  parameters:
    decim: '4'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"black"'
    fc: freqPM
    fftsize: '1024'
    label1: Moduladora
    label2: Modulada PM
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freqPM
    fftsize: '1024'
    label1: Demodulada PM
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: From 44Khz to 48Khz
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate*4
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [PMmodsource, '0', low_pass_filter_1, '0']
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_fm_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_phase_modulator_fc_0, '0', PMmodsink, '0']
- [analog_phase_modulator_fc_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_phase_modulator_fc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [integrate, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_throttle2_0, '0']
- [low_pass_filter_1, '0', integrate, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', analog_phase_modulator_fc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
